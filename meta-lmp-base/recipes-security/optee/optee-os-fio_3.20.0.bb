require optee-os-fio.inc

PV = "3.20.0+git"
SRCREV = "8cd98dc897857b2f4aba68db14e9128405cf66cf"
SRCBRANCH = "3.20+fio"
