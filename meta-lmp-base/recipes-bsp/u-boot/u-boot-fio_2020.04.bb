require u-boot-fio-common.inc

SRCREV = "86eec81ca34fde1809c68cf04783bc7d34cee7f7"
SRCBRANCH = "2020.04+fio"

DEFAULT_PREFERENCE = "-1"
