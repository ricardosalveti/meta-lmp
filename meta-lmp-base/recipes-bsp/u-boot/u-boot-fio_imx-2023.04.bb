UBOOT_REPO = "git://github.com/MrCry0/u-boot.git"

require u-boot-fio-common.inc

SRCREV = "c81a9ee817ca8cd2d785fb005862116ee513999f"
SRCBRANCH = "2023.04+lf-6.1.22-2.0.0-fio-porting"
LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

DEFAULT_PREFERENCE = "-1"
