SRC_URI = "git://github.com/rhinstaller/efivar.git;branch=main;protocol=https \
           file://determinism.patch \
           file://no-werror.patch"
